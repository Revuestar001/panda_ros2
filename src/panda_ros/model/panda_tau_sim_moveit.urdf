Commit message: 对齐了urdf中hand和finger的visual和collision，引入panda_moveit_config包

File: src/panda_ros/model/panda_tau_sim_moveit.urdf (robot description, URDF)
Before this commit: robot panda, 12 links, 11 joints
Joints:
- joint joint8: axis 0 0 0 -> (none)
- joint joint9: axis 0 0 0 -> (none)
